# Updated latest commit ID from Slimbootloader Repo
SRCREV = "df5bd0bc2a522afcb8945a6797592b04838db753"
LIC_FILES_CHKSUM = "file://LICENSE;md5=ef7fba7be2819ac13aaf5d0f842ce5d9"


DEPENDS:append= " python3-tomli-native"

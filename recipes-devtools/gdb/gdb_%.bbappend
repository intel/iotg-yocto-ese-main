# Enable python support in gdb
PACKAGECONFIG += "python"

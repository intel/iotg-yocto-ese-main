inherit gnu-efi
UEFI_NETBOOT_TFTPROOT ?= "uefi-netboot${GNU_EFI_ARCH}"
UEFI_NETBOOT_KERNEL ?= "${UEFI_NETBOOT_TFTPROOT}/${KERNEL_IMAGETYPE}"
UEFI_NETBOOT_INITRD ?= "${UEFI_NETBOOT_TFTPROOT}/initrd"

GTKBASE_RRECOMMENDS:append:class-target = " librsvg-gtk"

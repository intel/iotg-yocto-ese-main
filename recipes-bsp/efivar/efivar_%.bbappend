EXTRA_OEMAKE_class-native_append = " CCLD=${CCLD}"

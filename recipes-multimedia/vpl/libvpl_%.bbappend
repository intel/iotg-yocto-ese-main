FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-Add-hello-encode-jpeg-api2x-example.patch \
                 "

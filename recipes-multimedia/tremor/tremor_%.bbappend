SRC_URI = "git://gitlab.xiph.org/xiph/tremor.git;protocol=https"

LDFLAGS_append_class-native = " -fuse-ld=lld"

TOOLCHAIN_class-native = "clang"

unset YOCTO_ALTERNATE_EXE_PATH
export YOCTO_ALTERNATE_EXE_PATH= "${STAGING_BINDIR_NATIVE}/llvm-config"

DEPENDS:remove = "virtual/${TARGET_PREFIX}binutils-crosssdk"
DEPENDS:append = " virtual/${TARGET_PREFIX}binutils"

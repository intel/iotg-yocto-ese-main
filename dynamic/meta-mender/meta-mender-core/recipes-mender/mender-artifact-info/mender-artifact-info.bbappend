# do_compile doesn't regenerate properly
do_compile[nostamp] = "1"

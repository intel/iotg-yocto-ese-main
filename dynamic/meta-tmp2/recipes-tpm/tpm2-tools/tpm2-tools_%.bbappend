inherit bash-completion

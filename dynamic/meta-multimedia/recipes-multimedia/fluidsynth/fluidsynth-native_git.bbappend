# git://github.com/FluidSynth/fluidsynth.git, branch=2.2.x is removed. Use master branch.
# Fix is pushed to upstream meta layer https://lists.openembedded.org/g/openembedded-devel/message/100335

SRC_URI = "git://github.com/FluidSynth/fluidsynth.git;branch=master;protocol=https"

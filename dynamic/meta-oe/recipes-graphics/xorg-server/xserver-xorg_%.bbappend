# move to dynamic since xf86-video-qxl depends on meta-oe
# Commented the xf86-video-qxl install as it has server connectivity issues while cloning
# RRECOMMENDS:${PN}:append = " xf86-video-qxl"

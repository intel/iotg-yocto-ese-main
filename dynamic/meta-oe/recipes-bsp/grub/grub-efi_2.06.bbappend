# mokutil is moved to dynamic/meta-oe/recipes-bsp/mokutil
RRECOMMENDS:${PN}:append = " mokutil"

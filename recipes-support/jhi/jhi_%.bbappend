SYSTEMD_SERVICE_${PN} = "jhi.service"

FILES_${PN} += "\
                ${libdir}/lib*${SOLIBSDEV} \
                ${libdir}/dal/applets/SpoolerApplet.dalp \
                "



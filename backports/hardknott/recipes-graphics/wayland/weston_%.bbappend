# WA to avoid QA issues for Hardknott
WARN_QA:append = " unknown-configure-option"
ERROR_QA:remove = "unknown-configure-option"

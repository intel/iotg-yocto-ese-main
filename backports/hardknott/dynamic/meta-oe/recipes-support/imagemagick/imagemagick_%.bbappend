#DESCRIPTION = "bbappend file for meta-openembedded/meta-oe/recipes-support/imagemagick/imagemagick_7.0.10.bb"

SRC_URI = "git://github.com/ImageMagick/ImageMagick.git;branch=main;protocol=https"

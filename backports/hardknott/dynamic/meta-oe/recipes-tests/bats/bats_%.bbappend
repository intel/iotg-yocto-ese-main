# hardknott QA issue due to ${libdir} points to /lib64
FILES_${PN} += "${nonarch_libdir}"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append = "file://0001-parser-Add-support-for-CAP_CHECKPOINT_RESTORE.patch"

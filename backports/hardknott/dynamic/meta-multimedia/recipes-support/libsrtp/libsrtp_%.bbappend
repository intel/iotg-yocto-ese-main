# bbappend file for meta-openembedded/meta-multimedia/recipes-support/libsrtp/libsrtp_2.3.0.bb

SRC_URI = "git://github.com/cisco/libsrtp.git;branch=main;protocol=https"
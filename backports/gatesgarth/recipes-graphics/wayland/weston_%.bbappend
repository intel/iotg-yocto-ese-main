# WA to avoid compilation issues for Gatesgarth
WARN_QA_append = " unknown-configure-option"
ERROR_QA_remove = "unknown-configure-option"

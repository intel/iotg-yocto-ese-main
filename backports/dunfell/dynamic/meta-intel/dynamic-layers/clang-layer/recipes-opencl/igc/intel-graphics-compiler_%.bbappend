# disabled for dunfell
PACKAGECONFIG:remove = "vc"

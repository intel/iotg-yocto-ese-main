# bbappend file for openembedded-core/meta/recipes-sato/puzzles/puzzles_git.bb
SRC_URI:remove = "git://git.tartarus.org/simon/puzzles.git;branch=master"
SRC_URI:prepend = "git://git.tartarus.org/simon/puzzles.git;branch=main "

# in addition to 20190815
LICENSE = "MIT"

inherit allarch packagegroup

RDEPENDS_${PN} = "\
	i915-additional-fw-drm \
"

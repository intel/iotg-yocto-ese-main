# gatesgarth already has compress module support
# This is to add packageconfig for the same
PACKAGECONFIG:append = " xz"
